# Keil uVision project stm32f103xb_bl.uvprojx, settings and files
target stm32f103xb_bl (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F415KBU7-4 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: stm32f103xb_bl +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: DAPLINK_VERSION=254, AT32F415KBU7_4,USE_STDPERIPH_DRIVER,MSC_ENDPOINT, DAPLINK_BL, DAPLINK_BUILD_KEY=0x9B939D93, DRAG_N_DROP_SUPPORT, OS_TICK=10000, INTERFACE_AT32F415, USE_HAL_DRIVER, STM32F103xB, DAPLINK_HIC_ID=0x97969908, __packed=__packed, DAPLINK_NO_ASSERT_FILENAMES, OS_CLOCK=144000000
  c misc: --gnu --c99 --no_unaligned_access --no_unaligned_access
  c include: ../Libraries/usb;../Libraries/daplink;./applications;..\Libraries\CMSIS\Include;../Libraries/hic_hal;../Libraries/daplink/drag-n-drop;../Libraries/daplink/settings;../Libraries/target;../Libraries/rtos_none;../Libraries/hic_hal/at32/at32f415;..\Libraries\CMSIS\Device;..\Libraries\AT32F4xx_StdPeriph_Driver\inc
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=254,-DMSC_ENDPOINT,-DDAPLINK_BL,-DDAPLINK_BUILD_KEY=0x9B939D93,-DDRAG_N_DROP_SUPPORT,-DOS_TICK=10000,-DINTERFACE_STM32F103XB,-DUSE_HAL_DRIVER,-DSTM32F103xB,-DDAPLINK_HIC_ID=0x97969908,-D__packed=__packed,-DDAPLINK_NO_ASSERT_FILENAMES,-DOS_CLOCK=72000000 --no_unaligned_access
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ../Libraries/daplink/daplink.sct
  link misc: --predefine="-DDAPLINK_BL" --predefine="-I..\Libraries\hic_hal\stm32\stm32f103xb"
  group board
    ./applications/: stm32f103xb_bl.c
  group applications
    ../Libraries/daplink/: circ_buf.c cortex_m.c crc16.c crc32.c error.c flash_hal.c HardFault_Handler.c info.c sdk_stub.c util.c validation.c
    ./applications/: daplink.c main.c SVC_Table.s
  group drag-n-drop
    ../Libraries/daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
  group hic_hal
    ../Libraries/hic_hal/at32/at32f415/: flash.c gpio.c read_uid.c uart.c usbd_STM32F103.c usbd_AT32F4xx.c
    ../Libraries/hic_hal/stm32/stm32f103xb/: usb_config.c
    ../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_tim.c at32f4xx_usart.c misc.c
    ../Libraries/CMSIS/Device/: system_at32f4xx.c
    ../Libraries/CMSIS/Device/startup/mdk/: startup_at32f415kbu7-4.s
  group rtos
    ../Libraries/rtos_none/: cmsis_os2_port.c SysTick_Handler.c
  group settings
    ../Libraries/daplink/settings/: settings.c settings_rom_stub.c
  group target
    ../Libraries/target/: target_board.c
  group usb
    ../Libraries/usb/: usbd_core.c
    ../Libraries/usb/msc/: usbd_core_msc.c usbd_msc.c
