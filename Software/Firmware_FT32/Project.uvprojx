# Keil uVision project Project.uvprojx, settings and files
target FT32F0xB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FT32F072KBBUx FMD
  pack: FMD.FT32F0xx_DFP.1.1.3
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FT32F072xB
  c include: .\Applications;.\Drivers;.\Libraries\CMSIS\FT32F0xx\Include;.\Libraries\FT32F0xx_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Applications
    ./Applications/: main.c
  group Drivers
    ./Drivers/: ft32f0xx_it.c drv_led.c systick.c
  group CMSIS
    ./Libraries/CMSIS/FT32F0xx/source/: system_ft32f0xx.c
    ./Libraries/CMSIS/FT32F0xx/source/arm/: startup_ft32f072xb.s
  group FT32F0xx_Driver
    ./Libraries/FT32F0xx_Driver/Src/: ft32f0xx_adc.c ft32f0xx_debug.c ft32f0xx_dma.c ft32f0xx_flash.c ft32f0xx_gpio.c ft32f0xx_misc.c ft32f0xx_pwr.c ft32f0xx_rcc.c ft32f0xx_rtc.c ft32f0xx_spi.c ft32f0xx_syscfg.c ft32f0xx_tim.c ft32f0xx_usart.c
