# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: -AT32F425K8U7-4 ArteryTek
  pack: ArteryTek.AT32F425_DFP.2.0.9
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARM_LIBC, CONFIG_USB_DWC2_PORT=FS_PORT, AT32F425K8U7_4, __CLK_TCK=RT_TICK_PER_SECOND, USE_STDPERIPH_DRIVER, __RTTHREAD__, RT_USING_LIBC
  c include: applications;..\..\third_party\CherryUSB\class\hid;drivers;..\..\rt-thread\components\drivers\include;..\..\third_party\CherryUSB\class\dfu;board\inc;..\..\rt-thread\components\drivers\include;..\..\third_party\CherryUSB\class\msc;..\..\rt-thread\libcpu\arm\common;..\..\third_party\CherryUSB\core;..\..\third_party\CherryUSB\common;..\..\rt-thread\components\libc\posix\io\poll;..\..\rt-thread\components\libc\compilers\common\extension;..\..\rt-thread\libcpu\arm\cortex-m4;.;..\..\rt-thread\components\libc\posix\ipc;..\..\third_party\CherryUSB\class\cdc;..\..\third_party\CherryUSB\class\video;..\..\rt-thread\components\drivers\include;libraries\AT32F425_Firmware_Library\cmsis\cm4\core_support;drivers\config;..\..\rt-thread\include;..\..\third_party\DAPLink\DAP;libraries\AT32F425_Firmware_Library\drivers\inc;..\..\rt-thread\components\libc\compilers\common\include;..\..\third_party\CherryUSB\class\wireless;..\..\rt-thread\components\libc\posix\io\stdio;..\..\third_party\DAPLink\SWD_host;..\..\third_party\CherryUSB\class\audio;..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;board;libraries\AT32F425_Firmware_Library\cmsis\cm4\device_support
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c cmsis-dap.c
  group CherryUSB
    ../../third_party/CherryUSB/core/: usbd_core.c
    ../../third_party/CherryUSB/class/cdc/: usbd_cdc.c
    ../../third_party/CherryUSB/port/dwc2/: usb_dc_dwc2.c
  group Compiler
    ../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m4/: context_gcc.S cpuport.c
  group DAPLink
    ../../third_party/DAPLink/DAP/: DAP.c SW_DP.c
    ../../third_party/DAPLink/SWD_host/: SWD_host.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    board/src/: at32_msp.c board.c
    drivers/: drv_common.c drv_gpio.c drv_usart_v2.c
    libraries/AT32F425_Firmware_Library/cmsis/cm4/device_support/startup/mdk/: startup_at32f425.s
  group Kernel
    ../../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/AT32F425_Firmware_Library/drivers/src/: at32f425_spi.c at32f425_crm.c at32f425_adc.c at32f425_acc.c at32f425_crc.c at32f425_i2c.c at32f425_gpio.c at32f425_wdt.c at32f425_ertc.c at32f425_misc.c at32f425_scfg.c at32f425_dma.c at32f425_usart.c at32f425_debug.c at32f425_exint.c at32f425_pwc.c at32f425_flash.c at32f425_tmr.c at32f425_can.c at32f425_usb.c at32f425_wwdt.c
    libraries/AT32F425_Firmware_Library/cmsis/cm4/device_support/: system_at32f425.c
