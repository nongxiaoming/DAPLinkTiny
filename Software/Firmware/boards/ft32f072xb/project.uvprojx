# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FT32F072RBATx FMD
  pack: FMD.FT32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_LIBC, FT32F072xB, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: ..\..\rt-thread\components\libc\posix\io\stdio;.;..\..\third_party\CherryUSB\class\msc;..\..\rt-thread\include;..\..\third_party\CherryUSB\class\video;..\..\rt-thread\components\finsh;..\..\rt-thread\libcpu\arm\cortex-m0;..\..\third_party\DAPLink\SWD_host;..\..\third_party\CherryUSB\class\dfu;..\..\third_party\CherryUSB\class\audio;..\..\rt-thread\components\libc\posix\ipc;applications;..\..\third_party\CherryUSB\core;..\..\third_party\CherryUSB\class\cdc;..\..\rt-thread\components\libc\compilers\common\extension;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;board;libraries\FT32F0xx\CMSIS\FT32F0xx\Include;..\..\third_party\CherryUSB\class\wireless;libraries\FT32F0xx\FT32F0xx_Driver\Inc;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\libc\posix\io\poll;..\..\third_party\CherryUSB\common;..\..\third_party\CherryUSB\class\hid;..\..\rt-thread\components\libc\compilers\common\include;..\..\third_party\DAPLink\DAP;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;Drivers;libraries\FT32F0xx\FT32F0xx_Driver\templates\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    ./applications/: cdc_acm_hid_msc_template.c
  group CherryUSB
    ../../third_party/CherryUSB/core/: usbd_core.c
    ../../third_party/CherryUSB/class/hid/: usbd_hid.c
    ../../third_party/CherryUSB/port/musb/: usb_dc_musb.c usb_glue_es.c
    ../../third_party/CherryUSB/class/cdc/: usbd_cdc_acm.c
  group Compiler
    ../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/serial/: serial.c
  group Drivers
    Drivers/: drv_gpio.c drv_usart.c
    board/: board.c
    libraries/FT32F0xx/CMSIS/FT32F0xx/source/arm/: startup_ft32f072xb.s
  group Finsh
    ../../rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/FT32F0xx/FT32F0xx_Driver/Src/: ft32f0xx_crs.c ft32f0xx_gpio.c ft32f0xx_pwr.c ft32f0xx_div.c ft32f0xx_crc.c ft32f0xx_syscfg.c ft32f0xx_usart.c ft32f0xx_dma.c ft32f0xx_tim.c ft32f0xx_comp.c ft32f0xx_debug.c ft32f0xx_rcc.c ft32f0xx_exti.c ft32f0xx_iwdg.c ft32f0xx_misc.c
    libraries/FT32F0xx/CMSIS/FT32F0xx/source/: system_ft32f0xx.c
