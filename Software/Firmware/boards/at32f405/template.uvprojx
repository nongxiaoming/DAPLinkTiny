# Keil uVision project template.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AT32F405RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.6
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
  scatter file: .\board\linker_scripts\link.sct
