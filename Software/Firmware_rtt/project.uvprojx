# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F415KBU7-4 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415KBU7_4, USE_STDPERIPH_DRIVER
  c include: applications;.;..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Device;..\Libraries\CMSIS\Include;..\Libraries\rt-thread\libcpu\arm\common;..\Libraries\rt-thread\libcpu\arm\cortex-m4;..\Libraries\rt-thread\components\drivers\include;..\Libraries\rt-thread\components\drivers\include;..\Libraries\rt-thread\components\drivers\include;..\Libraries\rt-thread\components\drivers\include;drivers;board;board\msp;..\Libraries\rt-thread\components\dfs\include;..\Libraries\rt-thread\components\dfs\filesystems\elmfat;..\Libraries\rt-thread\components\dfs\filesystems\devfs;..\Libraries\rt-thread\components\finsh;.;..\Libraries\rt-thread\include;..\Libraries\rt-thread\components\libc\compilers\common;..\Libraries\rt-thread\components\drivers\usb\usbdevice;..\Libraries\USB_Device_Library\Core\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group AT32F4xx_StdPeriph_Driver
    ../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_adc.c at32f4xx_can.c at32f4xx_crc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_sdio.c at32f4xx_acc.c at32f4xx_bkp.c at32f4xx_rtc.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_xmc.c at32f4xx_comp.c at32f4xx_dac.c misc.c
  group CMSIS
    ../Libraries/CMSIS/Device/: system_at32f4xx.c
  group cpu
    ../Libraries/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../Libraries/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../Libraries/rt-thread/components/drivers/misc/: pin.c adc.c
    ../Libraries/rt-thread/components/drivers/rtc/: rtc.c
    ../Libraries/rt-thread/components/drivers/serial/: serial.c
    ../Libraries/rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    drivers/: drv_usart.c drv_gpio.c drv_rtc.c
    board/: board.c
    board/msp/: at32_msp.c
    ../Libraries/CMSIS/Device/startup/mdk/: startup_at32f415kbu7-4.s
  group Filesystem
    ../Libraries/rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../Libraries/rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../Libraries/rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
    ../Libraries/rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group finsh
    ../Libraries/rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c
  group Kernel
    ../Libraries/rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rt_usbd
    ../Libraries/rt-thread/components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../Libraries/rt-thread/components/drivers/usb/usbdevice/class/: cdc_vcom.c hid.c
  group USB_Device_Library
    ../Libraries/USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
