# Keil uVision project bootloader.uvproj, settings and files
target bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: bootloader +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __RTX, AT32F415KBU7_4,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=2532
  c include: ..\USBStack\INC;..\Drivers;..\Applications;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device;..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    ../Applications/: flash_svc.c main.c RTX_Config.c usbd_user_cdc_acm.c usbd_user_hid.c usbd_user_msc.c version.c
  group Drivers
    ../Drivers/: flash_hal.c gpio.c read_uid.c usb_config.c vector_table.c usbd_STM32F4xx_FS.c
  group USBStack
    ../USBStack/SRC/: usbd_core.c usbd_msc.c usbd_core_msc.c usbd_core_hid.c usbd_hid.c
  group CMSIS
    ../../Libraries/CMSIS/Device/: system_at32f4xx.c
    ../../Libraries/CMSIS/Device/startup/mdk/: startup_at32f415kbu7-4.s
  group AT32F4xx_StdPeriph_Driver
    ../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_crc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
  group RTX
    ../rtos/: rt_Event.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c rt_List.c HAL_CM4.c
