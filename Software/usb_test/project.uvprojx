# Keil uVision project project.uvprojx, settings and files
target at32_usb (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F415KBU7-4 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: usb_test +hex
  AfterMake: fromelf.exe --bin -o ./usb_test.bin ./build/usb_test.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __RTX,AT32F415KBU7_4,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=2532,1461
  c include: .\Applications;.\Drivers;.\Libraries\USBStack\INC;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device;..\Libraries\AT32F4xx_StdPeriph_Driver\inc;.\Libraries\RTX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Applications
    ./Applications/: main.c SVC_Table.s usbd_user_cdc_acm.c usbd_user_hid.c
  group Drivers
    ./Drivers/: usb_config.c usbd_STM32F4xx_FS.c RTX_Config.c led.c
  group USBStack
    ./libraries/USBStack/SRC/: usbd_core.c usbd_core_hid.c usbd_hid.c
    ./Libraries/USBStack/SRC/: usbd_cdc_acm.c usbd_core_cdc.c
  group RTX
    ./Libraries/RTX/: rt_Event.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c rt_List.c HAL_CM3.c
  group CMSIS
    ../Libraries/CMSIS/Device/: system_at32f4xx.c
    ../Libraries/CMSIS/Device/startup/mdk/: startup_at32f415kbu7-4.s
  group AT32F4xx_StdPeriph_Driver
    ../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_crc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c misc.c
